<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\2.8TFT_ADC_Wave\2.8TFT_ADC_Wave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\2.8TFT_BG\2.8TFT_BG.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\2.8TFT_H_Show\2.8TFT_H_Show.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\2.8TFT_Image\2.8TFT_Image.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\2.8TFT_SD_H\2.8TFT_SD_H.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\2.8TFT_Show\2.8TFT_Show.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\2.8TFT_Touch\2.8TFT_Touch.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\2.8TFT_Touch_Key\2.8TFT_Touch_Key.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\4KEY\4KEY.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\4KEY_12864\4KEY_12864.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\4KEY_1602\4KEY_1602.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\4KEY_2.8TFT\4KEY_2.8TFT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ADC_IN0_12864\ADC_IN0_12864.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ADC_IN0_1602\ADC_IN0_1602.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ADC_IN0_2.8TFT\ADC_IN0_2.8TFT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Board Test All_430-L\Board Test All_430-L.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DS18B20\DS18B20.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DS18B20_12864\DS18B20_12864.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DS18B20_1602\DS18B20_1602.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DS18B20_2.8TFT\DS18B20_2.8TFT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\INFRARED\INFRARED.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LCD12864\LCD12864.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LCD12864-Picture\LCD12864-Picture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LCD1602\LCD1602.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LED8\LED8.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LED8_1\LED8_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LED8_Run\LED8_Run.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MSP430_TEMP\MSP430_TEMP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\NRF24L01\MCU-fasong\RF24L01-fasong.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\NRF24L01\PC-jieshou\RF24L01-jieshou.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\RS485\RS485.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIMERA_2.8\TIMERA_2.8.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIMERA_LED\TIMERA_LED.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART_1\uart_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART_2\UART_2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\WatchDog_LED\WatchDog_LED.ewp</path>
  </project>
  <batchBuild/>
</workspace>


